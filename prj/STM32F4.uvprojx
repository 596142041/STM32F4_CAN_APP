# Keil uVision project STM32F4.uvprojx, settings and files
target STM32F4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4_APP +hex
  AfterMake: fromelf.exe --bin -o $L@H.bin $L@H.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4
  c include: ..\bsp\inc;..\CMSIS\inc;..\CMSIS\asm;..\STM32F4xx_StdPeriph_Driver\inc;..\user\inc;..\FatFs\inc;..\FreeModbus\Fun\inc;..\FreeModbus\modbus\ascii;..\FreeModbus\modbus\functions;..\FreeModbus\modbus\include;..\FreeModbus\modbus\rtu;..\FreeModbus\modbus;..\FreeModbus\port\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0xf8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/src/: main.c user_config.c stm32f4xx_it.c
  group bsp
    ../bsp/src/: delay.c can_driver.c can_app.c USART1.c NRF24L01_Driver.c W25Q64BV.c os.c timer.c CANB.c
  group CMSIS
    ../CMSIS/src/: system_stm32f4xx.c
    ../CMSIS/asm/: startup_stm32f40_41xxx.s
  group Lib
    ../STM32F4xx_StdPeriph_Driver/src/: STM32F4xx_StdPeriph_Lib_V1_8_0.lib
  group Math_Lib
    ../CMSIS/Math_Lib/: IQmathLib-cm4f.lib arm_cortexM4lf_math.lib
  group FATFS
    ../FatFs/src/: ff.c sdio_sd.c diskio.c syscall.c unicode.c
  group Hex_to_bin
    ../bsp/src/: hex_to_bin.c
  group FreeModbus
    ../FreeModbus/modbus/ascii/: mbascii.c
    ../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../FreeModbus/modbus/rtu/: mbrtu.c mbcrc.c
    ../FreeModbus/modbus/tcp/: mbtcp.c
    ../FreeModbus/modbus/: mb.c
  group FreeModbus_Config
    ../FreeModbus/port/src/: port.c portevent.c portserial.c porttimer.c
  group FreeModbus_Fun
    ../FreeModbus/Fun/src/: Fun_41.c
